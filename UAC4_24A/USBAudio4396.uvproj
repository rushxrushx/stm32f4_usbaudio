# Keil uVision project USBAudio4396.uvproj, settings and files
target FS-4396 (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0805FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FS4 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS
  c include: HW\4396;CORE;USER;ALIENTEK;FWLIB\inc;OTGLIB\STM32_USB_OTG_Driver\inc;OTGLIB\STM32_USB_Device_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group cortexlib
    ./CORE/: startup_stm32f40_41xxx.s
  group fwlib
    ./FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c
  group usbotglib
    ./OTGLIB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group usbotgdevice
    ./OTGLIB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./USER/: usbd_usr.c usbd_desc.c usb_bsp.c
  group alientek
    ./ALIENTEK/: usart.c
  group hw
    ./HW/4396/: board.c
  group user
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c usbd_audio_core.c audio_out.c
